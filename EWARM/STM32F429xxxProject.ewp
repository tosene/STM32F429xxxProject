# IAR project STM32F429xxxProject.ewp, settings and files
configuration STM32F429xxxProject (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429BI ST STM32F429BI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_FULL_LL_DRIVER; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __ICCARM__; __IASMARM__; __FPU_PRESENT; __FPU_USED
  ICCARM.CCIncludePath2: ../Drivers/STM32F4xx_HAL_Driver/Inc; ..\Drivers\STM32F4xx_HAL_Driver\Src; ..\Drivers\CMSIS\Include; ..\STM32F4xx; ..\STARTUP\EWARM; ..\Complier; ..\Doc; ..\Application\App; ..\Application\Delay; ..\Application\SysTick; ..\Application\USART; ..\Application\GPIO; ..\Application\Random; ..\Application\IIC; ..\Application\OneWire; ..\Application\WM8510; ..\Application\AD5593; ..\Application\AT24Cxx; ..\Application\Debug; ..\Application\HVPP; ..\Application\HVSP; ..\Application\NVSP; ..\Application\IWDG; ..\Application\WWDG; ..\Application\SPI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F429xxxProject.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/AD5593
    ../Application/AD5593/: ad5593_cfg.c ad5593_cfg.h ad5593_lib.c ad5593_lib.h ad5593_task.c ad5593_task.h
  group Application/App
    ../Application/App/: main.c main.h
  group Application/AT24Cxx
    ../Application/AT24Cxx/: eeprom_cfg.c eeprom_cfg.h eeprom_lib.c eeprom_lib.h eeprom_task.c eeprom_task.h
  group Application/Debug
    ../Application/Debug/: debug_cfg.c debug_cfg.h debug_lib.c debug_lib.h debug_task.c debug_task.h
  group Application/Delay
    ../Application/Delay/: delay_lib.c delay_lib.h
  group Application/GPIO
    ../Application/GPIO/: gpio_cfg.c gpio_cfg.h gpio_lib.c gpio_lib.h gpio_task.c gpio_task.h
  group Application/HVPP
    ../Application/HVPP/: hvpp_cfg.c hvpp_cfg.h hvpp_lib.c hvpp_lib.h hvpp_task.c hvpp_task.h
  group Application/HVSP
    ../Application/HVSP/: hvsp_cfg.c hvsp_cfg.h hvsp_lib.c hvsp_lib.h hvsp_task.c hvsp_task.h
  group Application/IIC
    ../Application/IIC/: iic_cfg.c iic_cfg.h iic_lib.c iic_lib.h iic_task.c iic_task.h
  group Application/IWDG
    ../Application/IWDG/: iwdg_cfg.c iwdg_cfg.h iwdg_lib.c iwdg_lib.h iwdg_task.c iwdg_task.h
  group Application/LED
    ../Application/LED/: led_cfg.c led_cfg.h led_lib.c led_lib.h led_task.c led_task.h
  group Application/NVSP
    ../Application/NVSP/: nvsp_cfg.c nvsp_cfg.h nvsp_lib.c nvsp_lib.h nvsp_task.c nvsp_task.h
  group Application/OneWire
    ../Application/OneWire/: one_wire_cfg.c one_wire_cfg.h one_wire_lib.c one_wire_lib.h one_wire_task.c one_wire_task.h
  group Application/Random
    ../Application/Random/: random_cfg.c random_cfg.h random_lib.c random_lib.h random_task.c random_task.h
  group Application/SPI
    ../Application/SPI/: spi_cfg.c spi_cfg.h spi_lib.c spi_lib.h spi_task.c spi_task.h
  group Application/SysTick
    ../Application/SysTick/: systick_cfg.c systick_cfg.h systick_lib.c systick_lib.h systick_task.c systick_task.h
  group Application/USART
    ../Application/USART/: usart_cfg.c usart_cfg.h usart_lib.c usart_lib.h usart_task.c usart_task.h
  group Application/WM8510
    ../Application/WM8510/: wm8510_cfg.c wm8510_cfg.h wm8510_lib.c wm8510_lib.h wm8510_task.c wm8510_task.h
  group Application/WWDG
    ../Application/WWDG/: wwdg_cfg.c wwdg_cfg.h wwdg_lib.c wwdg_lib.h wwdg_task.c wwdg_task.h
  group Complier
    ../Complier/: complier_cfg.c complier_cfg.h complier_lib.c complier_lib.h
  group Doc
    ../Doc/: ReadMe.txt
  group Drivers/CMSIS
    ../STM32F4xx/: system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
  group STARTUP/EWARM
    ../STARTUP/EWARM/: startup_stm32f429xx.s
  group STM32F4xx
    ../STM32F4xx/: stm32f429xx.h stm32f4xx.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_ll.h
