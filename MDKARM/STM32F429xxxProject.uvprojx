# Keil uVision project STM32F429xxxProject.uvprojx, settings and files
target STM32F429xxxProject (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F429xxxProject
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F429xx
  c misc: --gnu
  c include: ..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Src;..\Drivers\CMSIS\Include;..\Complier;..\Doc;..\STM32F4xx;..\STARTUP\MDKARM;..\Application\APP;..\Application\GPIO;..\Application\USART;..\Application\Delay;..\Application\OneWire;..\Application\SysTick;..\Application\WM8510;..\Application\AD5593;..\Application\AT24Cxx;..\Application\Debug;..\Application\HVPP;..\Application\HVSP;..\Application\NVSP;..\Application\SPI;..\Application\IWDG;..\Application\WWDG;..\Application\Random;..\Application\IIC
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Complier
    ../Complier/: complier_cfg.c complier_cfg.h complier_lib.c complier_lib.h
  group Doc
    ../Doc/: ReadMe.txt
  group STM32F4xx
    ../STM32F4xx/: stm32f4xx.h stm32f4xx_it.c stm32f4xx_it.h stm32f429xx.h stm32f4xx_ll.h
  group STARTUP/MDKARM
    ../STARTUP/MDKARM/: startup_stm32f429xx.s
  group Application/App
    ../Application/App/: main.c main.h
  group Application/GPIO
    ../Application/GPIO/: gpio_cfg.c gpio_cfg.h gpio_lib.c gpio_lib.h gpio_task.c gpio_task.h
  group Application/Delay
    ../Application/Delay/: delay_lib.c delay_lib.h
  group Application/SysTick
    ../Application/SysTick/: systick_cfg.c systick_cfg.h systick_lib.c systick_lib.h systick_task.c systick_task.h
  group Application/USART
    ../Application/USART/: usart_cfg.c usart_cfg.h usart_lib.c usart_lib.h usart_task.c usart_task.h
  group Application/OneWire
    ../Application/OneWire/: one_wire_cfg.c one_wire_cfg.h one_wire_lib.c one_wire_lib.h one_wire_task.c one_wire_task.h
  group Application/IIC
    ../Application/IIC/: iic_cfg.c iic_cfg.h iic_lib.c iic_lib.h iic_task.c iic_task.h
  group Application/AD5593
    ../Application/AD5593/: ad5593_cfg.c ad5593_cfg.h ad5593_lib.c ad5593_lib.h ad5593_task.c ad5593_task.h
  group Application/AT24Cxx
    ../Application/AT24Cxx/: eeprom_cfg.c eeprom_cfg.h eeprom_lib.c eeprom_lib.h eeprom_task.c eeprom_task.h
  group Application/IWDG
    ../Application/IWDG/: iwdg_cfg.c iwdg_cfg.h iwdg_lib.c iwdg_lib.h iwdg_task.c iwdg_task.h
  group Application/WWDG
    ../Application/WWDG/: wwdg_cfg.c wwdg_cfg.h wwdg_lib.c wwdg_lib.h wwdg_task.c wwdg_task.h
  group Application/Random
    ../Application/Random/: random_cfg.c random_cfg.h random_lib.c random_lib.h random_task.c random_task.h
  group Application/SPI
    ../Application/SPI/: spi_cfg.c spi_cfg.h spi_lib.c spi_lib.h spi_task.c spi_task.h
  group Application/HVSP
    ../Application/HVSP/: hvsp_cfg.c hvsp_cfg.h hvsp_lib.c hvsp_lib.h hvsp_task.c hvsp_task.h
  group Application/HVPP
    ../Application/HVPP/: hvpp_cfg.c hvpp_cfg.h hvpp_lib.c hvpp_lib.h hvpp_task.c hvpp_task.h
  group Application/NVSP
    ../Application/NVSP/: nvsp_cfg.c nvsp_cfg.h nvsp_lib.c nvsp_lib.h nvsp_task.c nvsp_task.h
  group Application/WM8510
    ../Application/WM8510/: wm8510_cfg.c wm8510_cfg.h wm8510_lib.c wm8510_lib.h wm8510_task.c wm8510_task.h
  group Application/Debug
    ../Application/Debug/: debug_cfg.c debug_cfg.h debug_lib.c debug_lib.h debug_task.c debug_task.h
  group Drivers/CMSIS
    ../STM32F4xx/: system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
software components: CMSIS:CORE 4.3.0
